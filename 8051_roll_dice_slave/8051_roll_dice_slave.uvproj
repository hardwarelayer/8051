# Keil uVision project 8051_roll_dice_slave.uvproj, settings and files
target Target 1 (MCS-51)
  device: W78E052 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0-0x1FFF) CLOCK(40000000)
  output: 8051_roll_dice_slave +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c delay.SRC tientn.SRC
