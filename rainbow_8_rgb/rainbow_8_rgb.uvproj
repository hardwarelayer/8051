# Keil uVision project rainbow_8_rgb.uvproj, settings and files
target Target 1 (MCS-51)
  device: W78E052 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0-0x1FFF) CLOCK(40000000)
  output: rainbow_8_rgb +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
