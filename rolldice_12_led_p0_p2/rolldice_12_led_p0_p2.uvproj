# Keil uVision project rolldice_12_led_p0_p2.uvproj, settings and files
target Target 1 (MCS-51)
  device: W78E052 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0-0x1FFF) CLOCK(40000000)
  output: rolldice_12_led_p0_p2 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c delay.SRC
